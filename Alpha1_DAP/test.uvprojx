# Keil uVision project test.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: FreeRTOS_F407 +hex
  AfterMake: fromelf.exe --bin -o mcubin\iLuxCurePro.bin .\Objects\FreeRTOS_F407.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5
  c define: STM32F40XX,USE_STDPERIPH_DRIVER,USE_USB_OTG_FS
  c include: .\Libraries\cmsis\Include;.\Libraries\cmsis\Source;.\Startup;.\User;.\Libraries\inc;.\User\hal;.\User\app;.\User\common;.\User\cpplib;.\User\mculib;.\User\user;.\User\freertos\Source\include;.\User\freertos\Source\portable\RVDS\ARM_CM4F;.\User\freertos;.\fatfs;.\usb\STM32_USB_HOST_Library\Class\MSC\inc;.\usb\STM32_USB_HOST_Library\Core\inc;.\usb\STM32_USB_OTG_Driver\inc;.\usb\USB_APP;.\User\freertos\Source\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group startup
    ./Startup/: startup_stm32f40_41xxx.s
  group cmsis
    ./Libraries/cmsis/Source/: system_stm32f4xx.c
  group fwlib
    ./Libraries/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group user
    ./User/: stm32f4xx_it.c
    ./User/user/: main.c config.c app.c debug.c hmi_driver.c ui_process.c setting.c version.c wifi_use.c data_upload.c ota_update.c ethernet_update.c dap_app.c
  group hal
    ./User/hal/: led.c spi.c w25qxx.c tim.c sdio_sdcard.c adc.c ntc.c dwt_delay.c htu21d.c ws2812b.c wifi_driver.c rtc.c ethernet_driver.c dap_motor.c
  group mculib
    ./User/mculib/: f4_uart.c stm32f4_sys.c f4_flash.c avflash.c
  group common
    ./User/common/: cmd.c com_fun.c comm_rec.c my_queue.c aos_crc64.c
  group FreeRTOS_Core
    ./User/freertos/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS_Port
    ./User/freertos/Source/portable/RVDS/ARM_CM4F/: port.c
    ./User/freertos/Source/portable/MemMang/: heap_4.c
  group fatfs
    ./fatfs/: diskio.c ff.c mycc936.c file_handing.c
  group usb_otg
    ./usb/STM32_USB_OTG_Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
  group usb_host
    ./usb/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
    ./usb/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_scsi.c
  group usb_app
    ./usb/USB_APP/: usb_bsp.c usbh_usr.c
